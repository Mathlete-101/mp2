Commit message: upgrade sim

File: osamu/moonpie_osamu/urdf/robot.urdf (robot description, URDF)
Before this commit: robot four_wheeled_robot, 6 links, 5 joints
Joints:
- joint world_to_base: origin xyz=0 0 0 rpy=0 0 3.14159 -> xyz=0 0 0 rpy=0 0 0
